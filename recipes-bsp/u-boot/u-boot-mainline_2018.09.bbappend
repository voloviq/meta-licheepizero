# M.Wolowik
# Copyright (C) 2018 EmSysLabs

DEFAULT_PREFERENCE_sun8i="1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
  	file://boot.cmd\
"