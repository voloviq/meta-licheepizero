PACKAGECONFIG_remove_sun7i = "xcomposite-egl xcomposite-glx wayland-egl wayland-glx"
