PACKAGECONFIG_append = "accessibility fontconfig linuxfb tslib"
PACKAGECONFIG_remove = "examples tests"
